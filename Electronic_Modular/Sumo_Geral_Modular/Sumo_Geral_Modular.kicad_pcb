# Repository project-neon/Ligeirinho

File README.md:

# Ligeirinho
Our 4th sumo robot, Ligeirinho

## KiCad design Electronic_Modular/Sumo_Geral_Modular/Sumo_Geral_Modular.kicad_pcb

Parts:
6_Pins_Button1: ON/OFF; Push_Button_6_pins
C1, C3, C5, C6, C7, C8, C9, C10: 100nF; C_0603_1608Metric
C2, C4: 10uF; C_0603_1608Metric
D1: BLUE; LED_0603_1608Metric
D2, D4: 1N4007; D_0603_1608Metric
D3, D5: RED; LED_0603_1608Metric
ESP1: ESP32-WROOM­32UE; ESP32-WROOM-32
H_Bridge1: H_Bridge_with_headers
J1: Bateria; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J2: VL53L0X 1; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J3: VL53L0X 2; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J4: VL53L0X 3; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J5: VS1838B; PinHeader_1x03_P2.00mm_Vertical
J6: EXT2; PinHeader_1x03_P2.00mm_Vertical
J7: EXT1; PinHeader_1x03_P2.00mm_Vertical
J8: Motor A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: Motor B; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: ESC1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J11: ESC2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J12: USB_B_Micro; USB_Micro-B_Amphenol_10118194_Horizontal
J13: ADSN-9500; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
J14: ADSN-9500-PS; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J15: MPU-6050; PinSocket_1x08_P2.54mm_Vertical
Q1, Q2: S8050; SOT-23
R1, R2: 4k7; R_0603_1608Metric
R3: 500R; R_0603_1608Metric
R4, R5: 1K; R_0603_1608Metric
R6, R7, R9, R11, R12, R14: 10K; R_0603_1608Metric
R8: 330; R_0603_1608Metric
R10: 10K; C_0603_1608Metric
R13: 130R; R_0603_1608Metric
SW2: EN; SW_SPST_TL3305C
SW3: BOOT; SW_SPST_TL3305C
U1: AMS1117-5.0; SOT-223-3_TabPin2
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: CH340C; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
3V3: C4.1, C7.1, C9.1, C10.1, ESP1.2 (3V3), H_Bridge1.13 (STDBY), J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J14.1, J15.1, R1.1, R2.1, R9.2, R13.1, R14.2, U2.2 (VO), U3.4 (V3), U3.16 (VCC)
5V: C3.1, D2.1 (K), D4.1 (K), U2.3 (VI)
AIN1: ESP1.11 (IO26), H_Bridge1.14 (AIN1)
AIN2: ESP1.10 (IO25), H_Bridge1.15 (AIN2)
BAT: 6_Pins_Button1.2 (O2), 6_Pins_Button1.4 (Output), C1.1, H_Bridge1.1 (VM), R3.1, R12.2, U1.3 (VI)
BIN1/ESC1: ESP1.13 (IO14), H_Bridge1.12 (BIN1), J10.1
BIN2/ESC2: ESP1.12 (IO27), H_Bridge1.11 (BIN2), J11.1
DDT: ESP1.9 (IO33), R10.1, R11.2
EN: C5.2, C8.1, ESP1.3 (EN), Q1.3 (C), R14.1, SW2.1
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, D1.1 (K), D3.1 (K), D5.1 (K), ESP1.1 (GND), ESP1.15 (GND), ESP1.38 (GND), ESP1.39 (GND), H_Bridge1.3 (GND), H_Bridge1.8 (GND), H_Bridge1.9 (GND), J1.2, J2.2, J3.2, J4.2, J5.2, J6.3, J7.3, J10.3, J11.3, J12.5 (GND), J12.6 (Shield), J14.2, J15.2, J15.7, R11.1, SW2.2, SW3.2, U1.1 (GND), U2.1 (GND), U3.1 (GND)
INT: ESP1.8 (IO32), J15.8
IO0: C6.1, ESP1.25 (IO00), Q2.3 (C), R9.1, SW3.1
IO34: ESP1.6 (IO34), J6.2
IO35: ESP1.7 (IO35), J7.2
IR: ESP1.5 (SensorVN/39), J5.3
MISO: ESP1.31 (IO19), J13.2
MOSI: ESP1.37 (IO23), J13.4
MOTION: ESP1.16 (IO13), J13.5
unnamed: 6_Pins_Button1.C (I2), J1.1
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), J12.1 (VBUS)
unnamed: D3.2 (A), R8.2
unnamed: C2.1, D4.2 (A), U1.2 (VO)
unnamed: D5.2 (A), R13.2
unnamed: ESP1.24 (IO02), R8.1
unnamed: H_Bridge1.4 (AO1), J8.1
unnamed: H_Bridge1.5 (AO2), J8.2
unnamed: H_Bridge1.7 (BO1), J9.1
unnamed: H_Bridge1.6 (BO2), J9.2
unnamed: J12.3 (D+), U3.5 (UD+)
unnamed: J12.2 (D-), U3.6 (UD-)
unnamed: Q1.2 (B), R6.1
unnamed: Q1.1 (E), R7.2, U3.14 (~RTS)
unnamed: Q2.2 (B), R7.1
unnamed: Q2.1 (E), R6.2, U3.13 (~DTR)
unnamed: R10.2, R12.1
unnamed: R5.2, U3.3 (RXD)
unnamed: R4.2, U3.2 (TXD)
RXD0: ESP1.34 (IO03), R4.1
SCL: ESP1.36 (IO22), J2.3, J3.3, J4.3, J15.3, R1.2
SCLK: ESP1.30 (IO18), J13.3
SDA: ESP1.33 (IO21), J2.4, J3.4, J4.4, J15.4, R2.2
SS/CS: ESP1.29 (IO05), J13.1
TXD0: ESP1.35 (IO01), R5.1
XSH1: ESP1.26 (IO04), J2.5
XSH2: ESP1.27 (IO16), J3.5
XSH3: ESP1.28 (IO17), J4.5

Notes on the sheet:
SENSORS
ESP-32 MODULES
BOOT/RESET SWITCHES
MICRO USB AND USB-UART
POWER SUPPLY AND SYSTEM REGULATORS
MOUSE SENSOR AND POWER-SOURCE (PS) TO THE MOUSE SENSOR
FOR BRUSHLESS MOTORS
VOLTAGE DIVIDER
FOR BRUSHED MOTORS
PULL-UP FOR I2C COMMUNICATION
IR SENSOR FOR JUDGE COMMANDS
IMU SENSOR
DISTANCE SENSORS
BOOT
RESET

Board: 2 copper layers, 43.3 x 62.9 mm, 54 parts (19 on the bottom side), 47 nets.

## KiCad design Electronics/ligeirinho.kicad_pcb

Parts:
C1: 10uF; CP_Radial_D5.0mm_P2.50mm
C2: 100uF; CP_Radial_D6.3mm_P2.50mm
C3, C4, C5: 10uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1: Bateria; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J2: ESP32 esq; PinSocket_1x15_P2.54mm_Vertical
J3: ESP32 dir; PinSocket_1x15_P2.54mm_Vertical
J4: VL53L0X 1; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
J5: VL53L0X 2; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
J6: VL53L0X 3; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
J7: Motor A; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J8: Motor B; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J9: ponte H ld motores; PinSocket_1x08_P2.54mm_Vertical
J10: ponte H ld ESP; PinSocket_1x08_P2.54mm_Vertical
J11: VS1838B; PinHeader_1x03_P2.54mm_Vertical
J12: MPU6050; PinSocket_1x08_P2.54mm_Vertical
J13: ADNS-9500; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
J14: ADNS-9500 3V3; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
R1, R2: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SW_Push; Nidec_Copal_SH-7010C
U1: LM7805_TO220; TO-220-3_Vertical
U2: ESP32_DevKit_V1_DOIT; esp32_devkit_v1_doit
U3: TB6612FNG; TB6612FNG_Dual_Motor_Driver_Carrier
U4: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
2s: C1.1, J9.1, SW1.2, U1.1 (VI)
3V3: C3.1, C4.1, C5.1, C7.1, J4.1, J5.1, J6.1, J10.4, J11.3, J12.1, J14.1, R1.2, R2.2, U4.2 (VO)
5V: C2.1, C6.1, J2.15, U1.3 (VO), U2.15 (VIN), U4.3 (VI)
AIN1: J2.6, J10.2, U2.6 (IO32)
AIN2: J2.7, J10.3, U2.7 (IO33)
AO1: J7.2, J9.4
AO2: J7.1, J9.5
BIN1: J2.8, J10.5, U2.8 (IO25)
BIN2: J2.9, J10.6, U2.9 (IO26)
BO1: J8.2, J9.7
BO2: J8.1, J9.6
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.1, J2.14, J3.14, J4.2, J5.2, J6.2, J10.8, J11.2, J12.2, J12.7, J14.2, U1.2 (GND), U2.14 (GND), U2.17 (GND), U4.1 (GND)
INT: J3.12, J12.8
IR: J2.4, J11.1, U2.4 (IO34)
MISO sm: J3.6, J13.2, U2.25 (IO19)
MOSI sm: J3.1, J13.4, U2.30 (IO23)
unnamed: J1.2, SW1.1
unnamed: U3.1 (AO1), U3.2 (AO1)
unnamed: U3.3 (PGND1), U3.4 (PGND1)
unnamed: U3.5 (AO2), U3.6 (AO2)
unnamed: U3.7 (BO2), U3.8 (BO2)
unnamed: U3.9 (PGND2), U3.10 (PGND2)
unnamed: U3.11 (BO1), U3.12 (BO1)
SCL: J3.2, J4.3, J5.3, J6.3, J12.3, R2.1, U2.29 (IO22)
SDA: J3.5, J4.4, J5.4, J6.4, J12.4, R1.1, U2.26 (IO21)
SS/CS: J3.8, J13.1, U2.18 (IO15)
XSHUT1: J3.9, J4.5, U2.22 (IO17)
XSHUT2: J3.10, J5.5, U2.21 (IO16)
XSHUT3: J3.11, J6.5, U2.20 (IO4)
motion: J2.10, J13.5, U2.10 (IO27)
sclk: J3.7, J13.3, U2.24 (IO18)

Board: 2 copper layers, 76.9 x 55.9 mm, 26 parts (7 on the bottom side), 25 nets.

## Commit log

2023-10-03 test: add MPU6050, VL53L0X and I2C Scan tests
2023-10-16 feat(Electronics): add ESP32 symbol, Footprint and 3D
2023-10-18 test: add Judge IR controller sensor test
2023-10-18 test: add motors test
2023-10-22 chore: rename tests
2023-10-31 chore: add connections images
2023-10-31 chore: update .gitignore to not allow auto backups
2023-12-28 chore: add electronic repository of ligerinho
2023-12-28 shore: update electronic repository
2023-12-29 shore: organized tags, add footprints and esp32 schematic
2024-01-13 shore: update PCB repository
2024-01-15 shore: add stickers
2024-01-16 shore: add measures
2024-01-16 fix(Electronics): add VIN tag to PCB
2024-01-17 fix: add 10uF capacitors and stitching
2024-01-17 add: AMS1117 to 3v3 regulator
2024-01-17 fix: add some more stitching GND holes
2024-01-23 chore: add mouse sensor to pcb and fix some measures
2024-01-23 fix: change pcb size from 76mm to 77mm
2024-02-07 test: add mouse test prototype
2024-02-12 tests(MouseSensor): make the code cleaner
2024-02-29 feat: add autonomous stategy
2024-03-01 fix: absolute value x and y
2024-03-13 fix(IRSensor): fix to Sony controller values
2024-03-13 fix: change I2C speed comm to 400kHz
2024-03-13 fix: motorsOutput() mistype
2024-03-13 feat: start using mouse sensor to control the robot
2024-03-16 feat: add PID to controll the robot
2024-03-16 feat: rc controller
2024-03-21 feat: add new PD controller to y axis
2024-05-15 feat: add mechanical files
2024-05-18 chore: init modular PCB
2024-06-01 chore: continue development modular pcb
2024-06-15 chore: finish the schematic and set footprints
2024-06-15 chore: set all footprints
2024-07-13 shore: update PCB
2024-08-31 shore: PCB review
2024-09-14 shore: schematic final review
2024-09-14 chore(Electronics): new symbols and footprints
2024-09-16 chore: Add/Update 3D models on PCB
2024-09-17 teste
2024-10-10 chore: prepare to robochallenge
2024-11-20 chore: schamatic review
2024-11-20 chore: change PCB size
2024-11-21 chore: finish PCB V1
2024-11-21 chore: application of DRC and error correction
2024-12-04 chore: update PCB and schematic
2024-12-04 chore: update resistors values
2024-12-17 chore: create GERBER file
2025-01-20 feat: add first internet test
2025-01-20 chore[Internet.ino]: use ESPAsyncWebServer and clean code
2025-01-25 chore: update net to console infos
2025-01-25 feat: add internet to autonomous
2025-02-01 chore: add strategies buttons, fix motors & pins, add strategy internet
2025-02-10 Chore: turn off internet
2025-02-14 chore: changes for the competion, weslley pc
2025-03-16 chore: Create PDFs and images
2025-09-08 docs(Mechanics): add drawings
2025-09-08 docs(Electronics): fix folders so that modular PCB is in Electronics
